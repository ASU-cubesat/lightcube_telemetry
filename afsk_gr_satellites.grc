options:
  parameters:
    generate_options: qt_gui
    id: afsk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '300'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '200'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '2'
    step: '1'
    stop: '30'
    value: '2'
  states: {}
- name: packen_len
  id: variable
  parameters:
    value: '52'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: samples_per_symbol
  id: variable_qtgui_range
  parameters:
    start: '2'
    step: '1'
    stop: '30'
    value: '16'
  states: {}
- name: samples_per_symbol_0
  id: variable_qtgui_range
  parameters:
    start: '2'
    step: '1'
    stop: '30'
    value: '2'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.1'
    stop: '1'
    value: '.1'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: audio_rate/(2*math.pi*fsk_deviation_hz)
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"beacon_real"'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '"telemetry"'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/lindsay/src/gnu_radio_dtmf/gqrx_20230116_235623_437141200_1800000_fc.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '8'
    n: '12'
    offset: '0'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 0.05*16
    max_dev: '1'
    nfilters: '2'
    osps: '1'
    pfb_mf_taps: '3'
    resamp_type: digital.IR_MMSE_8TAP
    sps: (audio_rate/baud_rate)/10
    ted_gain: 1.47*(1/16)
    ted_type: digital.TED_GARDNER
    type: ff
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '2125'
    decim: '1'
    samp_rate: audio_rate
    taps: firdes.low_pass(1.0,audio_rate,300,100)
    type: fcf
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '250'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: fff
  states: {state: disabled}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '2125'
    baudrate: baud_rate
    deviation: '100'
    samp_rate: audio_rate
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {state: disabled}
- name: satellites_reflect_bytes_0
  id: satellites_reflect_bytes
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '250'
    sync: '"010100101110111011001110001010101110010110100110111000100110"'
    threshold: '1'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_throttle_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', analog_nbfm_rx_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', network_udp_sink_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, satellites_reflect_bytes_0, in]
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', satellites_afsk_demodulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_keep_m_in_n_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_afsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_afsk_demodulator_0, '0', qtgui_sink_x_0, '0']
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print]
- [satellites_reflect_bytes_0, out, blocks_message_debug_0, print]
- [satellites_reflect_bytes_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [satellites_reflect_bytes_0, out, satellites_hexdump_sink_0, in]
- [satellites_sync_to_pdu_packed_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_sync_to_pdu_packed_0, out, satellites_print_timestamp_0, in]

metadata:
  file_format: 1
  grc_version: 3.9.8.0
